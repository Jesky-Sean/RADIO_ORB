options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: defu
  id: variable
  parameters:
    value: '"sysdefault"'
  states: {}
- name: hw
  id: variable
  parameters:
    value: '"hw:H6,0"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: variable_band_reject_filter_taps_0
  id: variable_band_reject_filter_taps
  parameters:
    gain: '1.0'
    samp_rate: samp_rate
    type: band_reject
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    type: float
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_24
    file: /home/sean/audioSamples/AttackerHomeBase_iir8
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '1094'
    long_form: 'True'
    type: ff
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: '3'
    type: fff
  states: {state: disabled}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '600'
    win: window.WIN_BLACKMAN
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '2'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: '1024'
    frame_rate: '30'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'False'
    type: float
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: pdu_add_system_time_0
  id: pdu_add_system_time
  parameters:
    key: pmt.intern("system_time")
  states: {state: disabled}
- name: pdu_pdu_filter_0
  id: pdu_pdu_filter
  parameters:
    invert: 'False'
    k: pmt.intern("key")
    v: pmt.intern("value")
  states: {state: disabled}
- name: pdu_pdu_split_0
  id: pdu_pdu_split
  parameters:
    pass_empty: 'True'
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: float
  states: {state: disabled}
- name: pdu_take_skip_to_pdu_0
  id: pdu_take_skip_to_pdu
  parameters:
    skip: '4096'
    take: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '5000'
    fc: '0'
    fftsize: '2048'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1'
    type: float
  states: {}
- name: variable_qtgui_distanceradar_0
  id: variable_qtgui_distanceradar
  parameters:
    ticklabels: '[''20'', ''40'', ''60'', ''80'', ''100'']'
  states: {state: disabled}

connections:
- [audio_source_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_rms_xx_0_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_tag_gate_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_throttle2_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [dc_blocker_xx_0_0, '0', high_pass_filter_0_0, '0']
- [fft_filter_xxx_0, '0', logpwrfft_x_0, '0']
- [fft_filter_xxx_0, '0', pdu_take_skip_to_pdu_0, '0']
- [high_pass_filter_0_0, '0', blocks_throttle2_0_0, '0']
- [high_pass_filter_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [iir_filter_xxx_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [pdu_add_system_time_0, pdu, pdu_pdu_filter_0, pdus]
- [pdu_pdu_filter_0, pdus, pdu_pdu_split_0, pdu]
- [pdu_pdu_split_0, dict, variable_qtgui_distanceradar_0, radius]
- [pdu_pdu_split_0, vec, pdu_pdu_to_stream_x_0, pdus]
- [pdu_pdu_split_0, vec, variable_qtgui_distanceradar_0, radius]
- [pdu_pdu_to_stream_x_0, '0', blocks_wavfile_sink_0_0, '0']
- [pdu_take_skip_to_pdu_0, pdus, pdu_add_system_time_0, pdu]
- [pdu_take_skip_to_pdu_0, pdus, pdu_pdu_split_0, pdu]
- [single_pole_iir_filter_xx_0_0, '0', blocks_wavfile_sink_0_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
