options:
  parameters:
    author: seanMJ
    description: Listens to all network aspects i can find and utilize.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: FmModListen
    output_language: python
    realtime_scheduling: '1'
    title: AllSeeingEye_Of_Attacks
  states: {}

blocks:
- name: BandPass_hg_B
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: BandPass_lw_B
  id: variable
  parameters:
    value: '1'
  states: {}
- name: BitsScale_C
  id: variable
  parameters:
    value: '6'
  states: {}
- name: PolyphsdrDecimations_C
  id: variable
  parameters:
    value: '2'
  states: {}
- name: QuatGain_C
  id: variable
  parameters:
    value: '3'
  states: {}
- name: RMS_
  id: variable
  parameters:
    value: '00.5'
  states: {}
- name: TransitionWidth
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: audioDecimations
  id: variable
  parameters:
    value: '3'
  states: {}
- name: audioPass
  id: variable
  parameters:
    value: '200'
  states: {}
- name: audioPass_C
  id: variable
  parameters:
    value: '300'
  states: {}
- name: audioStop
  id: variable
  parameters:
    value: '4700'
  states: {}
- name: audioStop_C
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: channelRate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: channelRate_1
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: decimations
  id: variable
  parameters:
    value: '1'
  states: {}
- name: defu
  id: variable
  parameters:
    value: '"sysdefault"'
  states: {}
- name: fileName_DAT_AM_A
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/FirstRun_FirstWAVRun-DAT_AMMOD"'
  states: {state: disabled}
- name: fileName_DAT_B_BNDPASS
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_PerfectionPassFilter3"'
  states: {}
- name: fileName_DAT_PSKMOD_C
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_PSKMOD3"'
  states: {}
- name: fileName_METADAT_AM_A
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_Meta-FirstWAVRun_AMMOD3"'
  states: {}
- name: fileName_WAV_AM_A
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_WAVRun_AMMOD3.wav"'
  states: {}
- name: fileName_WAV_B
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_WAVRun_PerfectionPassFilter3"'
  states: {}
- name: fileName_WAV_PSKMOD_C
  id: variable
  parameters:
    value: '"/home/sean/audioSamples/DAT/aug-2026/8142026_WAVRun_PSKMOD3"'
  states: {}
- name: gain_C
  id: variable
  parameters:
    value: '3'
  states: {}
- name: hw
  id: variable
  parameters:
    value: '"hw:H6,0"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samplesToSymbols
  id: variable
  parameters:
    value: '8'
  states: {}
- name: stopBand_C
  id: variable
  parameters:
    value: '100'
  states: {}
- name: taps_C
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps_C_0_0
  id: variable
  parameters:
    value: '3'
  states: {}
- name: variable_qtgui_range
  id: variable_qtgui_range
  parameters:
    start: '-140'
    step: '1'
    stop: '0'
    value: '-50'
  states: {state: disabled}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '-140'
    step: '1'
    stop: '0'
    value: '-50'
  states: {state: disabled}
- name: variable_qtgui_range_0_0
  id: variable_qtgui_range
  parameters:
    start: '-140'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: vec_sz
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vec_sz_1
  id: variable
  parameters:
    value: '1'
  states: {}
- name: BandpassRMS
  id: blocks_rms_xx
  parameters:
    alpha: RMS_
    type: float
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: decimations
    audio_pass: audioPass
    audio_stop: audioStop
    chan_rate: channelRate
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audioDecimations
    audio_pass: audioPass_C
    audio_stop: audioStop_C
    chan_rate: samp_rate
    deviation: '75000'
    gain: gain_C
    tau: '75e-6'
  states: {state: disabled}
- name: analog_fm_preemph_1
  id: analog_fm_preemph
  parameters:
    fh: '.05'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_preemph_1_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: QuatGain_C
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_2
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:H6,0
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '8000'
    interp: '1'
    low_cutoff_freq: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: BitsScale_C
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    comment: Overwrites Existing Saves Here instead of regular File Sink
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: fileName_METADAT_AM_A2
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sean/audioSamples/audioJustAttacker_pskmod.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: fileName_DAT_PSKMOD_C
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: fileName_DAT_B_BNDPASS
    type: float
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: fileName_DAT_AM_A
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: AttackOnUS-7-30-26
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters:
    vlen: vec_sz
  states: {}
- name: blocks_float_to_complex_1_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
    vlen: vec_sz
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '14'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '.5'
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '1'
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '3'
    type: float
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tag_gate_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_tag_gate_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
    vlen: vec_sz
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '3'
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    append: 'True'
    bits_per_sample1: FORMAT_FLOAT
    file: /home/sean/audioSamples/audioFromAttack_JustAttackersAttackspskMod
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    append: 'True'
    bits_per_sample2: FORMAT_PCM_24
    file: fileName_WAV_PSKMOD_C
    format: FORMAT_FLAC
    samp_rate: samp_rate
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: vec_sz+4096
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '1094'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    comment: changed 4 bits/symbol to 8
    constellation_points: '8'
    differential: 'True'
    excess_bw: '.2'
    freq_bw: 50.9/100.0
    improved_fll: 'True'
    log: 'True'
    mod_code: '"gray"'
    phase_bw: 3.28/100.0
    samples_per_symbol: samplesToSymbols
    timing_bw: 3.28/100.0
    verbose: 'True'
  states: {}
- name: filenameForData
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample2: FORMAT_PCM_24
    file: fileName_WAV_B
    format: FORMAT_FLAC
    samp_rate: samp_rate
  states: {}
- name: filenameForData_0
  id: blocks_wavfile_sink
  parameters:
    append: 'True'
    bits_per_sample2: FORMAT_PCM_24
    file: fileName_WAV_AM_A
    format: FORMAT_FLAC
    samp_rate: samp_rate
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '1.0'
    type: ccc
  states: {state: disabled}
- name: filter_fft_rrc_filter_1
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.55'
    decim: '1'
    gain: '1'
    ntaps: 11*samp_rate
    samp_rate: samp_rate
    sym_rate: '8.0'
    type: fff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '6'
    taps: '1'
    type: fff
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '3'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '600'
    win: window.WIN_BLACKMAN
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: '1'
    fftaps: '2'
    oldstyle: 'False'
    type: ffd
  states: {}
- name: ival_decimator_0
  id: ival_decimator
  parameters:
    decimation: '1'
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_BLACKMAN
  states: {}
- name: pfb_decimator_ccf_1
  id: pfb_decimator_ccf
  parameters:
    atten: stopBand_C
    channel: '0'
    decim: PolyphsdrDecimations_C
    taps: taps_C
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '7000'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.010'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    name: '"Whe He Is Talkng, And Where point'
    size: '4098'
    type: float
    update_time: '0.001'
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    rate: '.00010'
    showrf: 'True'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    rate: '.00010'
    showrf: 'True'
    type: float
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '256'
    nrows: '256'
    samp_rate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '3'
    size: '4098'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: float
    update_time: '0.010'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: float
  states: {state: disabled}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1'
    type: float
  states: {}

connections:
- [BandpassRMS, '0', blocks_tag_gate_0_1, '0']
- [analog_am_demod_cf_0, '0', blocks_throttle2_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', band_pass_filter_0_0_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0, '2']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0_1, '0']
- [analog_fm_preemph_1, '0', filter_fft_rrc_filter_1, '0']
- [analog_fm_preemph_1_0, '0', blocks_float_to_complex_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0_0, '0']
- [audio_source_0, '0', dc_blocker_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_throttle2_0, '0']
- [band_pass_filter_0_0, '0', qtgui_time_sink_x_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_throttle2_0_1, '0']
- [band_pass_filter_0_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0, '0', blocks_tag_gate_0, '0']
- [blocks_char_to_float_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_throttle2_0_1, '0']
- [blocks_float_to_complex_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_0_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_1, '0']
- [blocks_float_to_complex_0_0, '0', pfb_decimator_ccf_1, '0']
- [blocks_float_to_complex_1, '0', analog_am_demod_cf_0, '0']
- [blocks_float_to_complex_1_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rms_xx_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_rms_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', BandpassRMS, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_eye_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_rms_xx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_tag_gate_0_0_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_streams_to_vector_0, '0', ival_decimator_0, '0']
- [blocks_tag_gate_0, '0', audio_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_file_sink_0, '0']
- [blocks_tag_gate_0, '0', blocks_float_to_complex_0, '0']
- [blocks_tag_gate_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_tag_gate_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_tag_gate_0, '0', filenameForData_0, '0']
- [blocks_tag_gate_0, '0', qtgui_number_sink_0, '0']
- [blocks_tag_gate_0, '0', qtgui_sink_x_0_1, '0']
- [blocks_tag_gate_0_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_tag_gate_0_1, '0', audio_sink_0_1, '0']
- [blocks_tag_gate_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_tag_gate_0_1, '0', blocks_streams_to_vector_0, '1']
- [blocks_tag_gate_0_1, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_throttle2_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle2_0_1, '0', qtgui_histogram_sink_x_0_0, '0']
- [blocks_throttle2_0_1, '0', qtgui_sink_x_0_0, '0']
- [blocks_throttle2_0_1, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_vector_to_stream_0, '0', audio_sink_0_2, '0']
- [dc_blocker_xx_0, '0', analog_fm_preemph_1, '0']
- [dc_blocker_xx_0, '0', analog_fm_preemph_1_0, '0']
- [dc_blocker_xx_0, '0', dc_blocker_xx_0_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_1, '0']
- [dc_blocker_xx_0_0, '0', high_pass_filter_0_0, '0']
- [digital_psk_demod_0, '0', blocks_char_to_float_0_0, '0']
- [filter_fft_rrc_filter_1, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', blocks_float_to_complex_1, '0']
- [high_pass_filter_0_0, '0', blocks_throttle2_0_0_0, '0']
- [iir_filter_xxx_0_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [ival_decimator_0, '0', audio_sink_0_2, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [pfb_decimator_ccf_1, '0', analog_fm_demod_cf_0, '0']
- [pfb_decimator_ccf_1, '0', digital_psk_demod_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_file_sink_0_0_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', filenameForData, '0']
- [single_pole_iir_filter_xx_0_0, '0', qtgui_time_raster_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
